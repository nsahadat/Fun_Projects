# Repository nsahadat/Fun_Projects

File README.md:

# Fun_Projects
Hobby hardware/software embedded projects:

#### Door_Lock project is built from scratch to control your own door lock using Mobile App via WiFi:
This project includes the following in 4 folders: 
1. PCB design of the board using KiCAD
2. Firmware development of the WiFi module ESP8266
3. Designing the mechanical 3D printed part in Solidworks
4. Android app is developed using MIT App Inventor

## KiCad design Door_Look/PCB_KiCAD/Door_Lock.kicad_pcb

Parts:
C1, C11: 10uF; C_0603
C2, C5, C6, C8: 0.1uF; C_0603
C3, C7, C9: 1uF; C_0603
C4, C13: 10nF; C_0603
C10, C12, C14: 100nF; C_0603
D3: LED; LED-5MM
J3: FTDI_CON; CON6
P1: USB_OTG; USB_Micro-B_Molex_47346-0001
Q1: MMBT3904_BEC; MMBT3904
R1: 200k; R_0603
R2: 1k; R_0603
R3, R4: 100k; R_0603
R5: 0; R_0603
R7: 122; R_0603
U1: push_button; push_switch
U2: LDO_SPX3819; SPX3819
U3: motor_con; motor_conn
U4: ULN2003A; ULN2003a
U5: ESP-12F; ESP12F
U6: mic
U7: LSM9DS1

Connections:
+3V3: C3.1, C7.1, C8.1, C10.1, C11.1, C14.1, J3.4 (VCC), R1.2, R2.2, R4.2, R5.2, U2.5 (Vout), U5.3 (EN), U5.8 (VCC), U7.1 (VDD_IO), U7.3 (VDD_IO), U7.22 (VDD), U7.23 (VDD)
+5V: C1.1, C2.1, C9.1, P1.1, U2.1 (VIN), U2.3 (EN), U3.5 (VCC), U4.9
/CS_A_G: U5.12 (IO10), U7.7 (CS_A/G)
/CS_M: U5.11 (IO09), U7.8 (CS_M)
/IN1: U4.1, U5.7 (IO13)
/IN2: U4.2, U5.6 (IO12)
/IN3: U4.3, U5.5 (IO14)
/IN4: U4.4, U5.4 (IO16)
/MISO: U5.10 (MISO), U7.5 (SDO_A/G), U7.6 (SDO_M)
/MOSI: U5.13 (MOSI), U7.4 (SDA/SDI/SDO)
/SCK: U5.14 (SCLK), U7.2 (SCL/SPC)
GND: C1.2, C2.2, C3.2, C4.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.2, J3.6 (GND), P1.5, P1.6, Q1.2 (E), R7.2, U1.1, U2.2 (GND), U4.8, U5.15 (GND), U5.16 (IO15), U6.2 (-), U7.14 (RES), U7.15 (RES), U7.16 (RES), U7.17 (RES), U7.18 (RES), U7.19 (GND), U7.20 (GND)
unnamed: C4.1, U2.4 (BP)
unnamed: C5.1, U5.2 (ADC)
unnamed: C5.2, Q1.3 (C), R1.1, R3.1
unnamed: C6.1, Q1.1 (B), R3.2
unnamed: C6.2, R2.1, U6.1 (+)
unnamed: C12.1, U7.24 (C1)
unnamed: C13.2, U7.21 (CAP)
unnamed: D3.1 (K), R7.1
unnamed: D3.2 (A), U5.17 (IO02)
unnamed: J3.2 (RX), U5.22 (TXD)
unnamed: J3.3 (TX), U5.21 (RXD)
unnamed: R4.1, U1.3, U5.18 (IO00)
unnamed: R5.1, U7.13 (DEN_A/G)
unnamed: U3.1 (IN1), U4.16
unnamed: U3.2 (IN2), U4.15
unnamed: U3.3 (IN3), U4.14
unnamed: U3.4 (IN4), U4.13

Notes on the sheet:
April 11th, 2017
Wi Home Project
Version: 0.2
POWER SUPPLY AC-->DC (5V) --> 3.3V SUPPLY
WiFi MODULE & RELAY INTERFACE, BUTTONS & INDICATORS
IMU: LSM9DS1

Board: 2 copper layers, 38.5 x 47.2 mm, 31 parts (0 on the bottom side), 29 nets.

## Commit log

2019-05-19 Automatic Doorlock using WiFi controller
2019-05-19 Android app
